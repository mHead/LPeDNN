# Keil uVision project sample.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.6.0
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: shish.hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: SIMULATOR
  c include: C:\Users\IlPaguro\AppData\Local\Arm\Packs\ARM\CMSIS\5.7.0\CMSIS\Include
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group startup_file
    ./: startup_LPC17xx.s
  group main
    ./: sample.cpp
  group lib_SoC_board
    ./: core_cm3.c system_LPC17xx.c
  group GLCD
    ./GLCD/: AsciiLib.h GLCD.h AsciiLib.cpp GLCD.cpp
  group TouchPanel
    ./TouchPanel/: TouchPanel.h TouchPanel.cpp
  group timers
    ./timer/: timer.h IRQ_timer.cpp lib_timer.cpp
  group setup
    ./setup/: setup.h setup.cpp
